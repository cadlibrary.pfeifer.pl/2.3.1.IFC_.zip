Properties of the parts of a building model (IFC4)

# File
Description: no view
File name: PGS 20 G1-B H=380.ifc
Time: 2025-01-21T12:11:56
Author: Aleksander Skuła
Organization: No Organization
Written by: ODA SDAI 24.5
Authorization: askula

# IfcBuildingElementProxy, Kotwa fundamentowa PGS 20/G1-B
In: PFEIFER
Material: B500B
AllplanAttributes - Typ_robót: Roboty betonowe; Nazwa obiektu: PGS 20/G1-B H=380; Nazwa: Kotwa fundamentowa PGS 20/G1-B; Materiał: B500B; Height: 380; Długość[mm] (lfdm): 970; Zestaw atrybutów obiektu: ElementAssembly; ID_komponentu_Allright: 0516ErE0000000003; Rodzaj rozliczenia: Szt
Pset_ManufacturerTypeInformation - Manufacturer: PFEIFER
