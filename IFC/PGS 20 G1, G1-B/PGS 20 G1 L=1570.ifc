Properties of the parts of a building model (IFC2X3)

# File
Description: no view
File name: C:\Users\askula\Desktop\PGS G1-B\PGS 20 G1 L=1570.ifc
Time: 2021-03-12T13:10:12
Author: Aleksander Skuła
Organization: No Organization
Written by: EDMsix Version 2.0100.09 Sep 7 2016
Made in: Allplan 2021.0 25.02.2021 - 08:18:14

# IfcBuildingElementProxy (2)
In: PFEIFER
Material: B500B
AllplanAttributes - Typ_robót: Roboty betonowe; Nazwa obiektu: PGS 20/G1 L=1570; Nazwa: Kotwa fundamentowa PGS 20/G1; Materiał: B500B; Długość[mm] (lfdm): 1570; Jednostka: Szt
Pset_ManufacturerTypeInformation - Manufacturer: PFEIFER
Name | ID_komponentu_Allright
Kotwa fundamentowa PGS 20/G1 | 0601ErE0000003321
Kotwa fundamentowa PGS 20/G1 | 0601ErE0000003407
