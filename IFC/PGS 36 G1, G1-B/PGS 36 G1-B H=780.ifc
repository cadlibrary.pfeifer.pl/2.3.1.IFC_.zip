Properties of the parts of a building model (IFC2X3)

# File
Description: no view
File name: P:\C. DOKUMENTACJA TECHNICZNA\C.2. - CAD - Biblioteka\2_PFEIFER\PFEIFER_SYSTEMY_PODPÓR_SŁ_ŚC_KOTWY\PGS G1 B + PCC\PGS G1-B 36\PGS 36 G1-B H=780.ifc
Time: 2021-04-02T14:07:48
Author: Aleksander Skuła
Organization: No Organization
Written by: EDMsix Version 2.0100.09 Sep 7 2016
Made in: Allplan 2021.0 17.03.2021 - 18:54:33

# IfcBuildingElementProxy, Kotwa fundamentowa PGS 36/G1-B
In: PFEIFER
Material: B500B
AllplanAttributes - Typ_robót: Roboty betonowe; Nazwa obiektu: PGS 36/G1-B H=780; Nazwa: Kotwa fundamentowa PGS 36/G1-B; Materiał: B500B; Height: 780; Długość[mm] (lfdm): 1590; ID_komponentu_Allright: 0601ErE0000009231; Jednostka: Szt
Pset_ManufacturerTypeInformation - Manufacturer: PFEIFER
