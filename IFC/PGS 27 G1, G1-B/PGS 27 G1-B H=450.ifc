Properties of the parts of a building model (IFC2X3)

# File
Description: no view
File name: PGS 27 G1-B H=450.ifc
Time: 2023-12-05T09:04:03
Author: Aleksander Skuła
Organization: No Organization
Written by: EDMsix Version 2.0.209.92 Dec 12 2020
Made in: Allplan 2022.1 28.09.2023 - 19:04:11

# IfcBuildingElementProxy, Kotwa fundamentowa PGS 27/G1-B
In: PFEIFER
Material: B500B
AllplanAttributes - Typ_robót: Roboty betonowe; Nazwa obiektu: PGS 27/G1-B H=450; Nazwa: Kotwa fundamentowa PGS 27/G1-B; Materiał: B500B; Height: 450; Długość[mm] (lfdm): 1280; ID_komponentu_Allright: 0520ErE0000000004; Jednostka: Szt
Pset_ManufacturerTypeInformation - Manufacturer: PFEIFER
