Properties of the parts of a building model (IFC2X3)

# File
Description: no view
File name: PGS 27 G1-B H=660.ifc
Time: 2024-01-18T13:03:05
Author: Aleksandra Bobyk
Organization: No Organization
Written by: ODA SDAI 23.9
Authorization: abobyk

# IfcBuildingElementProxy, Kotwa fundamentowa PGS 27/G1-B
In: PFEIFER
Material: B500B
AllplanAttributes - Typ_robót: Roboty betonowe; Nazwa obiektu: PGS 27/G1-B H=670; Nazwa: Kotwa fundamentowa PGS 27/G1-B; Materiał: B500B; Height: 670; Długość[mm] (lfdm): 1280; ID_komponentu_Allright: 0521ErE0000000741; Rodzaj rozliczenia: Szt
Pset_ManufacturerTypeInformation - Manufacturer: PFEIFER
