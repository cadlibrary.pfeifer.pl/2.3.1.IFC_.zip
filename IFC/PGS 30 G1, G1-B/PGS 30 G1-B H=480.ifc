Properties of the parts of a building model (IFC2X3)

# File
Description: no view
File name: C:\Users\askula\Desktop\PGS G1-B\PGS G1-B 30\PGS 30 G1-B H=480.ifc
Time: 2021-03-12T13:59:10
Author: Aleksander Skuła
Organization: No Organization
Written by: EDMsix Version 2.0100.09 Sep 7 2016
Made in: Allplan 2021.0 25.02.2021 - 08:18:14

# IfcBuildingElementProxy, Kotwa fundamentowa PGS 30/G1-B
In: PFEIFER
Material: B500B
AllplanAttributes - Typ_robót: Roboty betonowe; Nazwa obiektu: PGS 30/G1-B H=480; Nazwa: Kotwa fundamentowa PGS 30/G1-B; Materiał: B500B; Height: 480; Długość[mm] (lfdm): 1360; ID_komponentu_Allright: 0602ErE0000004721; Jednostka: Szt
Pset_ManufacturerTypeInformation - Manufacturer: PFEIFER
